<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LibEfsp.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>LIBRARY</name>
            <member>
                <project>LibEfsp</project>
                <configuration>Library</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
