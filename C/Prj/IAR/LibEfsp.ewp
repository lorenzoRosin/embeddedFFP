# IAR project LibEfsp.ewp, settings and files
configuration Library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Src; ..\..\Src\MsgEncoding\Inc; ..\..\Src\MsgEncoding\Src; ..\..\Src\MsgTxRx\Inc; ..\..\Src\MsgTxRx\Src; ..\..\ExtLib\embeddedCU\C\Src; ..\..\ExtLib\embeddedCU\C\Src\ByteStuffing\Inc; ..\..\ExtLib\embeddedCU\C\Src\Crc\Inc; ..\..\ExtLib\embeddedCU\C\Src\DataPacking\Inc; ..\..\ExtLib\embeddedCU\C\Src\Queue\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ../../Src/: eFSP_STANDARDTYPE.h eFSP_TYPE.h
  group MsgEncoding/Inc
    ../../Src/MsgEncoding/Inc/: eFSP_MSGD.h eFSP_MSGDPRV.h eFSP_MSGE.h
  group MsgEncoding/Src
    ../../Src/MsgEncoding/Src/: eFSP_MSGD.c eFSP_MSGE.c
  group MsgTxRx/Inc
    ../../Src/MsgTxRx/Inc/: eFSP_MSGRX.h eFSP_MSGRXPRV.h eFSP_MSGTX.h eFSP_MSGTXPRV.h
  group MsgTxRx/Src
    ../../Src/MsgTxRx/Src/: eFSP_MSGRX.c eFSP_MSGTX.c
