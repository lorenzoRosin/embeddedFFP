# IAR project eFSPTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Code\Inc; ..\..\Code\Src; ..\TestFunction\Inc; ..\TestFunction\Src; ..\..\ExtLib\embeddedCU\C\Code\Inc; ..\..\ExtLib\embeddedCU\C\Code\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eFSPTest.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group eFSP/Inc
    ../../Code/Inc/: eFSPByteUnStuffer.h eFSPMsgEncoder.h eFSPStandardType.h eFSPType.h
  group eFSP/Src
    ../../Code/Src/: eFSPByteUnStuffer.c eFSPMsgEncoder.c
  group ExtLib/embeddedCU/Inc
    ../../ExtLib/embeddedCU/C/Code/Inc/: eCUByteStuffer.h eCUByteUnStuffer.h eCUDataPack.h eCUDataUnPack.h eCUType.h
  group ExtLib/embeddedCU/Src
    ../../ExtLib/embeddedCU/C/Code/Src/: eCUByteStuffer.c eCUByteUnStuffer.c eCUDataPack.c eCUDataUnPack.c
  group Test
    ./: main.c
  group Test/Inc
    ../TestFunction/Inc/: eFSPByteStufferTest.h eFSPByteUnStufferTest.h eFSPDataStuffUnStuffTest.h
  group Test/Src
    ../TestFunction/Src/: eFSPByteStufferTest.c eFSPByteUnStufferTest.c eFSPDataStuffUnStuffTest.c
