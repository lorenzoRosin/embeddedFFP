# IAR project LibFsp.ewp, settings and files
configuration Library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\Code\Inc; ..\..\..\Code\Src; ..\..\..\ExtLib\embeddedCU\C\Code\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group Inc
    ../../../Code/Inc/: eFSPMsgDecoder.h eFSPMsgDecoder_Priv.h eFSPMsgEncoder.h eFSPMsgReceiver.h eFSPMsgReceiver_Priv.h eFSPMsgTransmitter.h eFSPMsgTransmitter_Priv.h eFSPStandardType.h eFSPType.h
  group Src
    ../../../Code/Src/: eFSPMsgDecoder.c eFSPMsgEncoder.c eFSPMsgReceiver.c eFSPMsgTransmitter.c
