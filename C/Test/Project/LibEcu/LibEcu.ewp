# IAR project LibEcu.ewp, settings and files
configuration Library (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\ExtLib\embeddedCU\C\Code\Inc; ..\..\..\ExtLib\embeddedCU\C\Code\Src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group Inc
    ../../../ExtLib/embeddedCU/C/Code/Inc/: eCUByteStuffer.h eCUByteStuffer_prv.h eCUByteUnStuffer.h eCUByteUnStuffer_prv.h eCUCircularQueue.h eCUCrc.h eCUCrcDigest.h eCUDataPack.h eCUDataUnPack.h eCUStandardType.h eCUType.h
  group Src
    ../../../ExtLib/embeddedCU/C/Code/Src/: eCUByteStuffer.c eCUByteUnStuffer.c eCUCircularQueue.c eCUCrc.c eCUCrcDigest.c eCUDataPack.c eCUDataUnPack.c
