# IAR project TestFsp.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Code\Inc; ..\..\Code\Src; ..\..\..\Code\Inc; ..\..\..\ExtLib\embeddedCU\C\Code\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TestFsp.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\LibFsp\Library\Exe\LibFsp.a; ..\LibEcu\Library\Exe\LibEcu.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group Inc
    ../../Code/Inc/: eFSPMsgDecoderTest.h eFSPMsgDeEncoderTest.h eFSPMsgEncoderTest.h eFSPMsgReceiverTest.h eFSPMsgRxTransmitterTest.h eFSPMsgTransmitterTest.h
  group Src
    ../../Code/Src/: eFSPMsgDecoderTest.c eFSPMsgDeEncoderTest.c eFSPMsgEncoderTest.c eFSPMsgReceiverTest.c eFSPMsgRxTransmitterTest.c eFSPMsgTransmitterTest.c
