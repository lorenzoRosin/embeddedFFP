<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\LibEcu\LibEcu.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\LibFsp\LibFsp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TestFsp.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Build</name>
            <member>
                <project>LibEcu</project>
                <configuration>Library</configuration>
            </member>
            <member>
                <project>LibFsp</project>
                <configuration>Library</configuration>
            </member>
            <member>
                <project>TestFsp</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
