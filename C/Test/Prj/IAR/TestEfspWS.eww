<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\LibEcu\LibEcu.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\LibEfsp\LibEfsp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TestEfsp.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Build</name>
            <member>
                <project>LibEcu</project>
                <configuration>Library</configuration>
            </member>
            <member>
                <project>LibEfsp</project>
                <configuration>Library</configuration>
            </member>
            <member>
                <project>TestEfsp</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
