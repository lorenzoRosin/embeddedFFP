# IAR project TestEfsp.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Code\Inc; ..\..\Code\Src; ..\..\..\Code\Inc; ..\..\..\ExtLib\embeddedCU\C\Code\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TestEfsp.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\LibEfsp\Library\Exe\LibEfsp.a; ..\LibEcu\Library\Exe\LibEcu.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
  group Inc
    ../../Code/Inc/: eFSP_MSGDTST.h eFSP_MSGDMSGETST.h eFSP_MSGETST.h eFSP_MSGRXTST.h eFSP_MSGRXMSGTXTST.h eFSP_MSGTXTST.h
  group Src
    ../../Code/Src/: eFSP_MSGDTST.c eFSP_MSGDMSGETST.c eFSP_MSGETST.c eFSP_MSGRXTST.c eFSP_MSGRXMSGTXTST.c eFSP_MSGTXTST.c
